v {xschem version=3.4.7 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} -200 100 0 0 {name=p1 lab=vmon}
C {devices/ipin.sym} -200 140 0 0 {name=p2 lab=s0}
C {devices/ipin.sym} -200 180 0 0 {name=p3 lab=s1}
C {devices/ipin.sym} -200 220 0 0 {name=p4 lab=clr}
C {devices/iopin.sym} -200 260 0 0 {name=p5 lab=vdd33}
C {devices/iopin.sym} -200 300 0 0 {name=p6 lab=gnd}
C {devices/opin.sym} -200 340 0 0 {name=p7 lab=live}
C {devices/opin.sym} -200 380 0 0 {name=p8 lab=sticky}
C {threshold_ref.sym} 0 400 0 0 {name=Xref}
C {devices/lab_pin.sym} -80 360 0 0 {name=p9 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} -80 380 0 0 {name=p10 sig_type=std_logic lab=s1}
C {devices/lab_pin.sym} -80 400 0 0 {name=p11 sig_type=std_logic lab=vdd33}
C {devices/lab_pin.sym} -80 420 0 0 {name=p12 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 80 360 0 0 {name=p13 sig_type=std_logic lab=vref}
C {devices/lab_pin.sym} 80 380 0 0 {name=p14 sig_type=std_logic lab=vth}
C {comparator.sym} 300 400 0 0 {name=Xcmp}
C {devices/lab_pin.sym} 220 360 0 0 {name=p15 sig_type=std_logic lab=vmon}
C {devices/lab_pin.sym} 220 380 0 0 {name=p16 sig_type=std_logic lab=vth}
C {devices/lab_pin.sym} 220 400 0 0 {name=p17 sig_type=std_logic lab=vdd33}
C {devices/lab_pin.sym} 220 420 0 0 {name=p18 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 380 360 0 0 {name=p19 sig_type=std_logic lab=flag}
C {glitch_filter.sym} 600 400 0 0 {name=Xfilt}
C {devices/lab_pin.sym} 520 370 0 0 {name=p20 sig_type=std_logic lab=flag}
C {devices/lab_pin.sym} 520 390 0 0 {name=p21 sig_type=std_logic lab=vdd33}
C {devices/lab_pin.sym} 520 410 0 0 {name=p22 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 680 370 0 0 {name=p23 sig_type=std_logic lab=flag_f}
C {flag_logic.sym} 900 400 0 0 {name=Xlogic}
C {devices/lab_pin.sym} 820 360 0 0 {name=p24 sig_type=std_logic lab=flag_f}
C {devices/lab_pin.sym} 820 380 0 0 {name=p25 sig_type=std_logic lab=clr}
C {devices/lab_pin.sym} 820 400 0 0 {name=p26 sig_type=std_logic lab=vdd33}
C {devices/lab_pin.sym} 820 420 0 0 {name=p27 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 980 360 0 0 {name=p28 sig_type=std_logic lab=live}
C {devices/lab_pin.sym} 980 380 0 0 {name=p29 sig_type=std_logic lab=sticky}
